require u-boot.inc

DEPENDS += "dtc-native"

SRCREV = "f3dd87e0b98999a78e500e8c6d2b063ebadf535a"

PV = "v2018.01+git${SRCPV}"
