FILESEXTRAPATHS_prepend := "${THISDIR}/lighttpd:"

PR := "${PR}.1"

